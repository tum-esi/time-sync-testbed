# IAR project lwip_ptpd_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; SKIP_SYSCLK_INIT; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; CPU_MIMXRT1062DVL6A; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; IMX_RT10XX; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; LWIP_PTP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/io; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/log; ../../../../../devices/MIMXRT1062/utilities; ../../../../../devices/MIMXRT1062/xip; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../middleware/lwip/contrib/apps; ../../../../../middleware/ptpd/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  ILINK.IlinkOutputFile: lwip_ptpd_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=512; __heap_size__=153600
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_ram_nonCacheable_DTCM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; CPU_MIMXRT1062DVL6A; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; IMX_RT10XX; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; LWIP_PTP=1
  ICCARM.CCIncludePath2: ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../../../../middleware/lwip/src/apps/httpsrv; ../../..; ../../../../../rtos/amazon-freertos/lib/include; ../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/utilities/io; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/log; ../../../../../devices/MIMXRT1062/utilities; ../../../../../devices/MIMXRT1062/xip; ../../../../../middleware/lwip/port; ../../../../../middleware/lwip/src; ../../../../../middleware/lwip/src/include; ../../../../../middleware/lwip/contrib/apps; ../../../../../middleware/ptpd/src
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; CPU_MIMXRT1062DVL6A; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; IMX_RT10XX; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; LWIP_PTP=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; CPU_MIMXRT1062DVL6A; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; IMX_RT10XX; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; LWIP_PTP=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor.icf
  group amazon-freertos/FreeRTOS
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_3.c
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
  group amazon-freertos/include
    ../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
    ../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group amazon-freertos/license
    ../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos/portable
    ../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c
  group board
    ../: fsl_phy.c fsl_phy.h pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_enet.c fsl_enet.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group lwip/port
    ../../../../../middleware/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group lwip/port/arch
    ../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src/api
    ../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../middleware/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/lwip
    ../../../../../middleware/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../middleware/lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip/src/include/netif/ppp
    ../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/include/posix
    ../../../../../middleware/lwip/src/include/posix/: errno.h netdb.h
  group lwip/src/include/posix/sys
    ../../../../../middleware/lwip/src/include/posix/sys/: socket.h
  group lwip/src/netif
    ../../../../../middleware/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group ptpd
    ../../../../../middleware/ptpd/src/: arith.c bmc.c constants.h datatypes.h display.c management.c protocol.c ptpd.c ptpd.h
  group ptpd/dep
    ../../../../../middleware/ptpd/src/dep/: constants_dep.h datatypes_dep.h msg.c net_mcu.c ptpd_dep.h servo.c startup_mcu.c sys_mcu.c timer_mcu.c
  group source
    ../: FreeRTOSConfig.h lwip_ptpd_freertos.c lwipopts.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
    ../../../../../devices/MIMXRT1062/: system_MIMXRT1062.c system_MIMXRT1062.h
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1062/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../../devices/MIMXRT1062/xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h evkmimxrt1060_sdram_ini_dcd.c evkmimxrt1060_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
